# IAR project K66_template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ICCARM.CCIncludePath2: source\common; source\drivers\inc; source\func\inc; source\Libs; source\Output; source\Startup; source\User
  OBJCOPY.OOCOutputFile: K66_template.srec
  ILINK.IlinkOutputFile: K66_template.out
  ILINK.IlinkIcfFile: Linker_Files\LQK66FLASH1M.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    source/common/: common.c common.h
  group drivers/ADC
    source/drivers/src/: ADC.c
    source/drivers/inc/: ADC.h
  group drivers/DMA
    source/drivers/src/: DMA.c
    source/drivers/inc/: DMA.h
  group drivers/EXTI
    source/drivers/src/: exti.c
    source/drivers/inc/: exti.h
  group drivers/FTM
    source/drivers/src/: FTM.c
    source/drivers/inc/: FTM.h
  group drivers/GPIO
    source/drivers/src/: GPIO.c
    source/drivers/inc/: GPIO.h GPIO_Cfg.h
  group drivers/I2C
    source/drivers/src/: I2C.c
    source/drivers/inc/: I2C.h
  group drivers/LPTMR
    source/drivers/src/: lptmr.c
    source/drivers/inc/: lptmr.h
  group drivers/PIT
    source/drivers/src/: PIT.c
    source/drivers/inc/: PIT.h
  group drivers/PLL
    source/drivers/src/: PLL.c
    source/drivers/inc/: PLL.h
  group drivers/PORT
    source/drivers/src/: port.c
    source/drivers/inc/: port.h
  group drivers/RTC
    source/drivers/src/: RTC.c
    source/drivers/inc/: RTC.h
  group drivers/SYSTICK
    source/drivers/src/: Systick.c
    source/drivers/inc/: Systick.h
  group drivers/UART
    source/drivers/src/: UART.c
    source/drivers/inc/: UART.h
  group drivers/WDOG
    source/drivers/src/: wdog.c
    source/drivers/inc/: wdog.h
  group func/FUNC
    source/func/src/: func.c
    source/func/inc/: func.h
  group func/MOTOR
    source/func/src/: motor.c
    source/func/inc/: motor.h
  group func/OLED
    source/func/src/: OLED.c
    source/func/inc/: OLED.h
  group func/STEER
    source/func/src/: steer.c
    source/func/inc/: steer.h
  group Libs
    source/Libs/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h MK66F18.h system_MK66F18.c system_MK66F18.h
  group Startup
    source/Startup/: crt0.s start.c vectors.c vectors.h
  group User
    source/User/: include.h isr.c isr.h main.c pid.c
  group User/LQ_I2C
    source/User/: u_iic.c u_iic.h
  group User/MPU6050
    source/User/: LQIIC6050.c LQMPU6050.h
  group User/V034
    source/User/: LQMT9V034.c LQMT9V034.h
